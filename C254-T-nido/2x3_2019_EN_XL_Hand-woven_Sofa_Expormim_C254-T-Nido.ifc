Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
Time: 2020-05-21T13:53:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 21 13:53:38 2020 * Host: Tatiana * Database: C:\Users\tatia\AppData\Local\Temp\{646B5997-FC57-4B44-A6EB-C105250C5D8D}\ifc * Database version: 5507 * Database creation date: Thu May 21 13:53:24 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 21 13:53:25 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 21 13:53:25 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: 2,20 x 0,86 x 0,77 m / 86.5" x 33.75" x 30.25", 2019_EN_XL_Hand-woven_Sofa_Expormim_C254-T-Nido:2,20 x 0,86 x 0,77 m / 86.5" x 33.75" x 30.25":112751
In: Level 1
Type - ElementType: 2,20 x 0,86 x 0,77 m / 86.5" x 33.75" x 30.25"; Material: Stainless Steel, Linen, White, Leather, Dark Brown, Linen, Beige
Type - Data - System: Furniture
Type - Dimensions - Height: 770 mm; Length: 2200 mm; SeatHeight: 400 mm; Weight: 24; Width: 860 mm
Type - Identity Data - Author: Bimetica Parametric Design Services SL; BIMEelementExpiryDate: 20/05/2021; BIMElementIssueDate: 20/05/2020; Bimetica: Bimetica.com; BimeticaProductProfileURL: https://bimetica.com/es/bim-object-expormim-nido-xl-hand-woven-sofa-javier-pastor-4733.html; BIM Support: https://bimsupport.info/es/fabricantes/expormim-bim/; CountryOfSale: AUSTRALIA, BELGIUM, CANADA, FRANCE, GERMANY, ISRAEL, ITALY, JAMAICA, JAPAN, JORDAN, KAZAKHSTAN, KENYA, KOREA, KOSOVO, KUWAIT, LATVIA, LEBANON, LIBYA, LITHUANIA, MACEDONIA, MALAYSIA, MALT, MOROCCO, MAURITIUS, MEXICO, MIDDLE EAST, NICARAGUA, NORWAY, NEW ZEALAND, PANAMA, PERU, POLAND, PORTUGAL, PUERTO RICO, QUATAR, UNITED KINGDOM, USA, REP.OF MALDIVES, REPUBLIC OF YEMEN, CZECH REPUBLIC, REPUBLIC OF SAN MARINO, DOMINICAN REPUBLIC, ROMANIA, RUSSIA, SENEGAL, SERBIA, SINGAPORE, SOUTH AFRICA, SPAIN, SRI LANKA, SWEDEN, SWITZERLAND, SULTANATE OF OMAN, THAILAND, TAIWAN, TUNISIA, TURKEY, UKRAINE, UNITED ARAB EMIRATES, URUGUAY, VENEZUELA, VIETNAM, VIRGIN ISLANDS,; Description: XL hand-woven sofa; Designer: Javier Pastor; IsExternal: yes; LicenseNumber: XXX-XXXX0359; Manufacturer: EXPORMIM S.A.; Model: C254 T XL hand-woven sofa; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Owner: EXPORMIM S.A.; ProductionYear: 2010; ProductURL: https://www.expormim.com/product_collections/outdoor/product_familys/nido/; SalesRepresentativeContact: export@expormim.com; Series: Nido; TechnicalInformation: https://downloads.expormim.com/direct/VqzDkg6Llp/folder/714; TechnicalSupportContact: expormim@bimsupport.info; TelephoneContact: 0034 962 295 144; Type Comments: Unique and exclusive pieces created by world-renowned designers with an outstanding career and much experience. Nido is a modular upholstered collection, with a structure made of stainless steel tube, thus guaranteeing outdoor use. I suggest that the structure be dressed in a denser rope braid in order to enrich the textures and finishes of this collection and provide greater warmth; Type Name: 2,20 x 0,86 x 0,77 m / 86.5" x 33.75" x 30.25"; URL: www.expormim.com; Version: RVT-2019
Type - Materials and Finishes - Collection: outdoor; Finish: Hand-woven armchair made of stainless steel tube, and finished with polyester powder. Hand-woven finish with high resistance rope 24 mm/0.94”.; HousingMaterial: Stainless Steel; PrimaryColor: explore expormim outdoor catalogue
Type - Other - Category: Furniture; Family Name: 2019_EN_XL_Hand-woven_Sofa_Expormim_C254-T-Nido
Pset_ManufacturerTypeInformation - Manufacturer: EXPORMIM S.A.; ProductionYear: 2010
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 5.66879 m2; Volume: 0.416036 m3
Other - Family: 2019_EN_XL_Hand-woven_Sofa_Expormim_C254-T-Nido: 2,20 x 0,86 x 0,77 m / 86.5" x 33.75" x 30.25"; Family and Type: 2019_EN_XL_Hand-woven_Sofa_Expormim_C254-T-Nido: 2,20 x 0,86 x 0,77 m / 86.5" x 33.75" x 30.25"; Type: 2019_EN_XL_Hand-woven_Sofa_Expormim_C254-T-Nido: 2,20 x 0,86 x 0,77 m / 86.5" x 33.75" x 30.25"; Type Id: 2019_EN_XL_Hand-woven_Sofa_Expormim_C254-T-Nido: 2,20 x 0,86 x 0,77 m / 86.5" x 33.75" x 30.25"
Phasing - Phase Created: New Construction
